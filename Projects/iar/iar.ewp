# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\CoxLib\inc; ..\..\ComPort; ..\..\Apps; ..\..\Utils; ..\..\Drivers\ArduinoMotorShield; ..\..\Drivers\Digital Accelerometer; ..\..\Drivers\Digital Compass; ..\..\Drivers\SensorShield; ..\..\Drivers\ServoMotor; ..\..\Drivers\\UltraSonic
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../Apps/: DriverCfg.h Interface.c Interface.h
  group ComPort
    ../../ComPort/: I2C_Channel.c I2C_Channel.h PortCfg.h SPI_Channel.c SPI_Channel.h UART_Channel.c UART_Channel.h
  group Driver/inc
    ../../Drivers/Digital Accelerometer/: ADXL345.h hw_ADXL345.h
    ../../Drivers/ArduinoMotorShield/: ArduinoMotorShield.h
    ../../Drivers/UltraSonic/: HC_SR04.h
    ../../Drivers/Digital Compass/: HMC5883L.h hw_HMC5883L.h
    ../../Drivers/SensorShield/: Sensor_shield.h
    ../../Drivers/ServoMotor/: ServoMotor.h
  group Driver/src
    ../../Drivers/Digital Accelerometer/: ADXL345.c
    ../../Drivers/ArduinoMotorShield/: ArduinoMotorShield.c
    ../../Drivers/UltraSonic/: HC_SR04.c
    ../../Drivers/Digital Compass/: HMC5883L.c
    ../../Drivers/SensorShield/: Sensor_Shield.c
    ../../Drivers/ServoMotor/: ServoMotor.c
  group Framework
    ../../Framework/: Frame.c
  group Libcox/inc
    ../../CoxLib/inc/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_adc.h xhw_config.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group Libcox/src
    ../../CoxLib/src/: xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group Startup
    ../../startup/: startup_ewarm.s
  group Utils
    ../../Utils/: cookie.h cookie_cfg.h DebugIO.c DebugIO.h ringbuf.c ringbuf.h
